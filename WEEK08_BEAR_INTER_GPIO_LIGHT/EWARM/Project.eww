<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\WEEK08_BEAR_INTER_GPIO_LIGHT.ewp</path>
  </project>
  <batchBuild />
</workspace>
